# IAR project Project_ns.ewp, settings and files
configuration B-U585I-IOT02A_TFM_Loader_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U585xx; USE_HAL_DRIVER; LOCAL_LOADER_CONFIG; BL2; _WIZCHIP_=5500
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Libraries; ..\..\..\..\..\..\Libraries\io6Library\Ethernet\W6100; ..\..\..\..\..\..\Libraries\io6Library\Internet\dhcp4; ..\..\..\..\..\..\Libraries\ioLibrary_Driver\Ethernet\W5100S; ..\..\..\..\..\..\Libraries\ioLibrary_Driver\Ethernet\W500; ..\..\..\..\..\..\Libraries\ioLibrary_Driver\Internet\dhcp; ..\..\..\..\..\..\Port\ioLibrary\inc; ..\..\Linker; ..\Secure_nsclib; ..\NonSecure\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: cmd /C "cmd /C postbuild.bat "nonsecure""
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c startup_stm32u5xx.c stm32u5xx_it.c tick.c ymodem.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Libraries
    ../../../../../../Libraries/: ioLibrary_file_include.c
  group Port/ioLibrary
    ../../../../../../Port/ioLibrary/src/: wiznet_interface.c wiznet_spi.c wiznet_time.c
