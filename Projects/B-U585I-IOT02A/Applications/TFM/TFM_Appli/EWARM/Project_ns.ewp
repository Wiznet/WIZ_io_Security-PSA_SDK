# IAR project Project_ns.ewp, settings and files
configuration B-U585I-IOT02A_TFM_Appli_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U585xx; USE_HAL_DRIVER; BL2; TFM_PSA_API; PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; TFM_PARTITION_INITIAL_ATTESTATION; TFM_LVL=2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; DOMAIN_NS=1; _WIZCHIP_=5500; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; SECURE_PRIVATE_KEY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\Linker; ..\NonSecure\Inc; ..\Secure_nsclib; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\mbedtls; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include\log; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; g\interface\include; ..\..\..\..\..\..\Examples; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\cmsis; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\framework; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\suites\crypto; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\secure_element\stm; ..\..\..\..\..\..\Libraries\aws-iot-device-sdk-embedded-C\libraries\standard\coreHTTP\source\include; ..\..\..\..\..\..\Libraries\aws-iot-device-sdk-embedded-C\libraries\standard\coreHTTP\source\dependency\3rdparty\http_parser; ..\..\..\..\..\..\Libraries\aws-iot-device-sdk-embedded-C\libraries\standard\coreMQTT\source\include; ..\..\..\..\..\..\Libraries\aws-iot-device-sdk-embedded-C\libraries\standard\corePKCS11\source\include; ..\..\..\..\..\..\Libraries; ..\..\..\..\..\..\Libraries\io6Library\Ethernet\W6100; ..\..\..\..\..\..\Libraries\io6Library\Internet\dhcp4; ..\..\..\..\..\..\Libraries\ioLibrary_Driver\Ethernet\W5100S; ..\..\..\..\..\..\Libraries\ioLibrary_Driver\Ethernet\W500; ..\..\..\..\..\..\Libraries\ioLibrary_Driver\Internet\dhcp; ..\..\..\..\..\..\Port\aws-iot-device-sdk-embedded-C\inc; ..\..\..\..\..\..\Port\ioLibrary\inc; ..\..\..\..\..\..\Port\mbedtls\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32U585xx"
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$"  "1.0.0" "nonsecure""
  ILINK.IlinkOutputFile: B-U585I-IOT02A.out
  ILINK.IlinkIcfFile: stm32u585xx_flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: B-U585I-IOT02A_S\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c mpu_armv8m_drv.c ns_data.c startup_stm32u5xx.c stm32u5xx_it.c test_protections.c tfm_app.c tfm_app_rot_ipc_api.c tfm_ns_lock.c ymodem.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Examples
    ../../../../../../Examples/: aws_iot_sample.c key_provisioning_sample.c loopback_sample.c
  group Libraries
    ../../../../../../Libraries/: ioLibrary_file_include.c
  group Libraries/aws-iot-device-sdk-embedded-C
    ../../../../../../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
    ../../../../../../Libraries/aws-iot-device-sdk-embedded-C/libraries/standard/corePKCS11/source/: core_pki_utils.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c code_share.c common.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_invasive.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/trustedfirmware/core
    ../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_firmware_update_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_ps_ipc_api.c tfm_psa_ns_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
  group Middlewares/trustedfirmware/test
    ../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto/: crypto_tests_common.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/test/framework/: test_framework.c test_framework_helpers.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/log/: tfm_log_raw.c
  group Port/aws-iot-device-sdk-embedded-C
    ../../../../../../Port/aws-iot-device-sdk-embedded-C/src/: dns_interface.c http_transport_interface.c key_provisioning.c mqtt_transport_interface.c ssl_transport_interface.c util.c
  group Port/ioLibrary
    ../../../../../../Port/ioLibrary/src/: wiznet_interface.c wiznet_spi.c wiznet_time.c
  group Port/mbedtls
    ../../../../../../Port/mbedtls/src/: entropy_poll_hw.c
